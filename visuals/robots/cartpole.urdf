Commit message: Visualise cartpole and acrobot

File: visuals/robots/cartpole.urdf (robot description, URDF)
Before this commit: robot inverted_pendulum, 4 links, 3 joints
Links:
- link slideBar: geometry visual box size=0.7 0.005 0.005
Joints:
- joint slider_to_cart: axis 1 0 0 -> -1 0 0
